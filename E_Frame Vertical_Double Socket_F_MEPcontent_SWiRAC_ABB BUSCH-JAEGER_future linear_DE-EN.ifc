Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-24T15:40:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 24 15:40:02 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\4a2a7b7e-aaa6-4ace-aaff-4e93a8de6c4c\9c114b9e-81d1-494b-8971-916d4fbabd56\ifc * Database version: 5507 * Database creation date: Mon Oct 24 15:40:01 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Oct 24 15:40:01 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 24 15:40:01 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOutlet: future linear_2CKA001754A4236_ver_2, E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN:future linear_2CKA001754A4236_ver_2:3021826
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 11 mm; Frame Thickness: 7 mm; Gang Height: 64 mm; Gang Width: 64 mm; Height: 151 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 1 mm; Rounding Radius: 0 mm; Width: 80 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: Studio white; Material: Color RAL 9016; Number of Gangs: 2
Type - Identity Data - Article Code: Default; Article Description: Future linear Cover frame, studio white, future linear cover frame; Article Type: 2-gang frame; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Future linear Cover frame, studio white, future linear cover frame; EMCS Version: 4.0; ETIM Article Class: EC000007; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395050767; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001754A4236; Manufacturer Type: 1722-184K; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001754A4236,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 2-gang frame; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: future linear; Revit Version: 2020; Type Name: future linear_2CKA001754A4236_ver_2; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN
Type - Pset_EnvironmentalImpactIndicators - Reference: future linear_2CKA001754A4236_ver_2
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: future linear_2CKA001754A4236_ver_2
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0193558 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.0000437775 m3
Electrical - Circuiting - Electrical Data: Power - Balanced2 230 V/1-200 VA-Power - Balanced1 230 V/1-200 VA
Electrical - Loads - Load Clasiffication: Power; Power: 200 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 220800
Other - Annotation Offset Position: 7 mm; Family: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN: future linear_2CKA001754A4236_ver_2; Family and Type: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN: future linear_2CKA001754A4236_ver_2; Gang 3: 71 mm; Gang Reference Line: 135 mm; Interior Width: 32 mm; Number of Representation Line: 2; Type: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN: future linear_2CKA001754A4236_ver_2; Type Id: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN: future linear_2CKA001754A4236_ver_2
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: future linear_with Earth 1F_2CKA002011A3725 (2)
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9016
Type - Constraints - Default Elevation: 2800 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 63 mm; Rounding Radius: 1 mm; Width: 63 mm
Type - Electrical - Material: Color RAL 9016; App ID: EL_MODELPARTSYSTEM; Insert Type: Studio white
Type - Identity Data - Custom: no; Article Code: Default; Article Description: SCHUKO socket outlet without claw, studio white, Socket outlets; Article Type: Socket outlet with PE recessed 1-fold; Base Family Version: 20221003; Category: EL_POWERCONSUMER; Content Supplier URL: www.MEPcontent.com; Description: SCHUKO socket outlet without claw, studio white, Socket outlets; EMCS Version: 4.0; ETIM Article Class: EC000125; Family Version: 11.23; GLN: 8712507900012; GTIN: 4011395996232; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA002011A3725; Manufacturer Type: 20 EUC-84; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA002011A3725,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; Model: Socket outlet with PE recessed 1-fold; OmniClass Number: 23.80.50.00; OmniClass Title: Terminals for Power Supply; Product Line: future linear; Revit Version: 2020; Type Name: future linear_with Earth 1F_2CKA002011A3725; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3725_DE-EN
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: future linear_with Earth 1F_2CKA002011A3725
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: future linear_with Earth 1F_2CKA002011A3725
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Annotation: 19; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00753861 m2; Volume: 0.0000387512 m3
Electrical - Loads - Load Classification: Power; Power: 0 W
Identity Data - Copyright: © Trimble Europe BV; VERSION: 220800
Other - Annotation SocketOneFoldWithEarth: yes; Family: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3725_DE-EN: future linear_with Earth 1F_2CKA002011A3725; Family and Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3725_DE-EN: future linear_with Earth 1F_2CKA002011A3725; Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3725_DE-EN: future linear_with Earth 1F_2CKA002011A3725; Type Id: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3725_DE-EN: future linear_with Earth 1F_2CKA002011A3725
Phasing - Phase Created: 4. Plan over 10 years
Name (E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3725_DE-EN:future linear_with Earth 1F_2CKA002011A3725:...) | Mark
3021830 | 6
3021831 | 7
